# Keil uVision project robot3.uvprojx, settings and files
target Robot3 (6190000::V6.19::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: robot3 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx
  c include: ..\..\RobotControl;..\LIB\STM32F4xx_StdPeriph_Driver\inc;..\Library\Inc;..\LIB\CMSIS\Device\ST\STM32F4xx\Include;..\..\Library_F4\LCD_I2C;..\..\Library_F4\LCD16X2;..\..\Library_F4\SYSTEM\IIC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: main.c stm32f4xx_it.c
  group LIB
    ../LIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../../Library_F4/LCD_I2C/: LCD_I2C.c
    ../../STM32F4xx_DSP_StdPeriph_Lib_V1.9.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_i2c.c
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK_ARM
    ../LIB/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group System
    ../../Library_F4/SYSTEM/IIC/: myiic.c
software components: CMSIS:CORE 5.6.0
